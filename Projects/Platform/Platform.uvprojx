# Keil uVision project Platform.uvprojx, settings and files
target iENBL (6210000::V6.21::ARMCLANG)
  device: STM32L496QEIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Platform
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x1000fb00 size 0x500
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0xfb00
  group App
    ./: Platform.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496QEIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496QEIx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32L496QEIx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:ITM 1.0.0, CMSIS-Compiler:STDIN:ITM 1.0.0, CMSIS-Compiler:STDOUT:ITM 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS Driver:I2C 1.2.0, CMSIS Driver:MCI 1.3.0, CMSIS Driver:SPI 1.5.0, CMSIS Driver:USART 1.4.0, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:I2C 1.13.0, Device:STM32Cube HAL:IRDA 1.13.0, Device:STM32Cube HAL:MMC 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:SD 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:STM32Cube HAL:Smartcard 1.13.0, Device:STM32Cube HAL:UART 1.13.0, Device:STM32Cube HAL:USART 1.13.0, Device:Startup 1.3.1
