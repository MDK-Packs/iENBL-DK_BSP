# Keil uVision project Blinky.uvprojx, settings and files
target iENBL (6140000::V6.14::ARMCLANG)
  device: STM32L496QEIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.1-dev4
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x1000fb00 size 0x500
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0xfb00
  group App
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496QEIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496QEIx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:Startup 1.3.1
